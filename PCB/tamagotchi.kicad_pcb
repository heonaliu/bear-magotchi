# Repository heonaliu/bear-magotchi

File README.md:

<div align="center">

# 🌸 Bearmagotchi

A custom bear-style case tamagotchi. Made by 17 y/o Heona Liu. This was my first full on hardware project, so I'm pretty proud of myself. Every step was a learning process: from KiCad interface, PCB routing, OnShape building, to coding with Arduino IDE for firmware and designing a zine.

This tamagotchi has 3 stats: hunger, energy, and happiness! You can play around with the different levels by using the buttons, each mapped to different functions. This was built by following [TaniWankenobi's](https://github.com/TaniWanKenobi) tamagotchi PCB tutorial. All 4 faces on the bearmagotchi are custom drawn!

## Why I Built This Project
I built this project because I have absolute 0 experience with hardware and wanted to learn! I find it so exciting to be able to design physical products! I'm more of a software person so working with hardware isn't easy for me. I procrastinated a lot because I was intimidated at first by hardware and its complexities, but I finally got the discipline and perseverance to start and finish this project. Throughout this project, I encountered many challenges and learning experiences, all which allowed me to further broaden my understanding of hardware and CAD. I also like cute things so this was a perfect project to build.

It took many trial and errors like learning how to solve DRC errors, rerouting, and being very confused at some points.

</div>

## Overview of how it works
Bearmagotchi was built with Seeed Studio XIAO ESP32-C3 and a custom PCB built with KiCad. OnShape was used to build the case design. Arduino IDE was used to code the button's functions with the OLED screen. There are three switches that you can press, which change the status of the pet's happiness, energy, and hungriness! 

### Key Parts Used:
- **Arduino MCU:** XIAO-ESP32-C3
- **Display:** 0.96" OLED screen
- **Power:** 3.7V rechargeable lithium polymer battery
- **Audio:** Buzzer -- [XHXDZ 1207-P6.5MM](https://www.lcsc.com/product-detail/C49246964.html)
- **Case:** Built with OnShape. View [Onshape CAD Link](https://cad.onshape.com/documents/021afe4b63c8b0b9c93cc183/w/f948377fc55dfd0736b0e217/e/5203c0fddfe92074836b1ae6?renderMode=0&uiState=6a3327ec9c87a1f6b1d3d4b6)
- **Firmware:** Arduino IDE in C++. Also wired and tested in a simulation in Wokwi.com. [Wokwi Link Here](https://wokwi.com/projects/467099855244316673)

- **Buzzer:** [XHXDZ 1207-P6.5MM](https://www.lcsc.com/product-detail/C49246964.html)
Switches: [BZCN TSC016A04518A](https://www.lcsc.com/product-detail/C2888493.html)
0.96" Oled Screen: [HS HS96L03W2C03](https://www.lcsc.com/product-detail/C5248080.html)

## Case Showcase
| **Top** | **Top Side View** |
| :--: | :--: |
|  | |
| **Bottom** | **Exploded View** |
|  | |

## PCB & Routing
| **Top** | **Top Routing Layer** |
| :--: | :--: |
|  | |
| **Bottom** | **Bottom Routing Layer** |
|  | |
|**Both**|
<div align="center">

</div>

## Schematic

## Bill of Materials -- BOM:
| **Item** | **Description** | **Value** | **LCSC Part** | **Qty** | **MOQ** | **Total Price** | **Links** |
| :--: | :--: | :--: | :--: | :--: |:--: |:--: | :--: |
| Battery | Cell battery to power | Battery_Cell | -- | 1 | 1 | $3.37 | [Purchase Link](https://www.aliexpress.us/item/3256805856928609.html?gatewayAdapt=glo2usa4itemAdapt)
| Buzzer | Buzzer for audio | 1207-P6.5MM | C49246964 | 1 | 10 | $0.57 | [Purchase Link](https://www.lcsc.com/product-detail/C49246964.html)
| Switch | Push button | TSC016A04518A | C2888493 | 3 | 50 | $0.54 | [Purchase Link](https://www.lcsc.com/product-detail/C2888493.html)
| OLED Display | 0.96" OLED | HS96L03W2C03 | C5248080 | 1 | 1 | $2.25 | [Purchase Link](https://www.lcsc.com/product-detail/C5248080.html)
| Seeed Studio ESP32-C3 MCU | MCU Arduino board | XIAO-ESP32-C3-SMD | -- | 1 | 1 | $4.54 | [Purchase Link](https://www.aliexpress.us/item/3256806793530218.html?gatewayAdapt=glo2usa4itemAdapt)
| PCB | Main board for building | -- | -- | 1 | 1 | $4.00 | --
|PCB Shipping | To UPS Account | -- | -- | -- | -- | $2.50 | --
| **Total** |  |  |  | **8** | **64** | **$17.77** | |

## Structural (Screws, Nuts) -- BOM:
| **Item** | **Description** | **Qty**  | **Total Price** | **Link**
| :--: | :--: | :--: | :--: |:--: |
| M3 x 25mm Screw | PH Countersunk flat head screw M3x0.5 x 25 Stainless Steel  | 2 | $1.74 | [Purchase Link](https://accu-components.com/us/countersunk-socket-head-screws/5430-SSK-M3-25-A2?google_shopping=1&c=2&gad_source=1&gad_campaignid=23876758716&gbraid=0AAAAADI7_w52Pj9fyJw7edzbYGgzAQiUG&gclid=Cj0KCQjwi8nRBhDhARIsAHZf_pZVKr8Kq71Xx-DJNwKNpfBIvS0pRFolBN9PN9_BSy07MO-u1rrJDKAaAufbEALw_wcB) |
| Hex Nut Grade A&B | M3x0.5  Stainless Steel  | 2 | $0.14 | [Purchase Link](https://belmetric.com/hex-nut-a2-stainless-din-934/?gad_source=1&gad_campaignid=21832963163&gbraid=0AAAAADn8Oc-E5kanGq3jWoaFNa1ESFVPE&gclid=Cj0KCQjwi8nRBhDhARIsAHZf_pacy6ZhzrGPmuq_yMzfeMh5XljB88UODfhdwc5PXWL3VzwXYlfHfLoaAkIGEALw_wcB&sku=NR3SS) |
| Total | | 4 | $1.88 | |

## Step by Step Assembly
| **Bottom case** | **Place PCB on top** |
| :--: | :--: |
|  | |
| **Place top cover aligned with the holes** | **Put in the M3 Screws & fasten with hex nuts** |
|  | |

## Firmware
Firmware utilizes Arduino using C++, listens for button presses, and changes OLED screen accordingly.
- Top Button: (Feed) -- makes pet less hungry
- Middle Button: (Play) -- increases happiness, decreases energy
- Bottom Button: (Sleep) -- sleeping (+energy)

Check out the simulation in Wokwi.com. [Wokwi Link Here!](https://wokwi.com/projects/467099855244316673)

### Screens
| **Happy (all >50)** | **Neutral (standard)** |
| :--: | :--: |
|  | |
| **Sad (a stat<30)** | **Sleep (on press)** |
|  | |

### How to use it
1. Arduino IDE > Settings and add into Additional Boards Manager URLS `https://espressif.github.io/arduino-esp32/package_esp32_index.json` - Click OK.
2. Tools > Board > Board Manager -- search `esp32 by Espressif Systems` and install (version should be 3+).
3. Create a fresh workspace
4. Tools > Board > esp32 > XIAO ESP32C3
5. Add the following libraries from Sketch > Include Library > Manage Libraries
- Adafruit SSD1306
- Adafruit GFX Library
6. Link project to machine through the USB-C cord. 
7. Copy the content in `bear.ino` to your sketch.
8. Click verify --> Upload to build

## Credits:
- This follows the tutorial by [TaniWankenobi](https://github.com/TaniWanKenobi)
- [Case tutorial](https://www.youtube.com/watch?v=7FC-pByCCXM) (for reference) by Pcb Cupid on YouTube
- README Structure, Formating & File Organization Inspiration: [DjukicAleksej](https://github.com/DjukicAleksej)

## Software Used
- Arduino IDE
- KiCad
- OnShape
- Visual Studio Code
- Procreate
- Wokwi
---
built with <3 by Heona Liu 2026

## KiCad design PCB/tamagotchi.kicad_pcb

Board: 2 copper layers, 80.5 x 69.3 mm, 7 parts (3 on the bottom side), 8 nets.

Parts:
BT1: Battery_Cell; PinHeader_1x02_P2.54mm_Vertical
BUZZER1: SUN-12095-5VPA7.6; BUZ-TH_BD12.0-P7.60-D0.6-FD
SW1, SW2, SW3: SW_Push; SW-TH_4P-L4.5-W4.5-P3.00-LS4.8
U1: XIAO-ESP32-C3-SMD; XIAO-ESP32-C3-DIP-SMD
U2: HS96L03W2C03; OLED-TH_L27.8-W27.2-P2.54_C9900033791

Connections:
+3.3V: U1.12 (3V3), U2.2 (VCC)
GND: BT1.2 (-), BUZZER1.2, SW1.1, SW2.1, SW3.1, U1.13 (GND), U2.1 (GND)
unnamed: BUZZER1.1 (+), U1.11 (GPIO10_D10_MOSI)
unnamed: SW1.2, U1.1 (GPIO2_A0_D0)
unnamed: SW2.2, U1.2 (GPIO3_A1_D1)
unnamed: SW3.2, U1.3 (GPIO4_A2_D2)
unnamed: U1.5 (GPIO6_D4_SDA), U2.4 (SDA)
unnamed: U1.6 (GPIO7_D5_SCL), U2.3 (SCL)

## Commit log

2026-06-12 commits inital
2026-06-13 update REAMDE
2026-06-15 add to README
2026-06-15 update gitignore
2026-06-16 update gitignore and remove duplicate files
2026-06-16 Removed cached files mentioned in .gitignore
2026-06-16 update files - remove unecessary ones
2026-06-17 add assembly .step file from onshape
2026-06-17 add Top and Bottom .step covers from onshape
2026-06-17 add component and screw files
2026-06-17 update gitignore to stop tracking ds_store
2026-06-17 add BOM csv file
2026-06-17 add firmware images
2026-06-17 add firmware
2026-06-17 track PCB files
2026-06-17 add PCB files
2026-06-17 add 3d models and symbol libraries via upload
2026-06-17 remove old image and add new images to firemware via upload
2026-06-17 add pcb 3d model
2026-06-17 add onshape link to README
2026-06-17 add Assembly images via upload
2026-06-17 move and add files via upload
2026-06-18 remove BG in many files
2026-06-18 upload BOM
2026-06-18 write README, add BOM, add description
2026-06-18 add assembly section
2026-06-18 add firmware section + complete majority of README
2026-06-18 update README with zine
2026-06-18 add via upload
2026-06-18 add software components to README
2026-06-21 move BOM outside into root folder
